SRC_URI += "file://bsp.cfg \
            file://user_2020-10-25-22-09-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
